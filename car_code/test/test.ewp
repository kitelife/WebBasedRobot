# IAR project test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3Sx9xx TexasInstruments LM3Sx9xx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: C:\StellarisWare\; C:\StellarisWare\inc; C:\StellarisWare\driverlib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: car1021.bin
  ILINK.IlinkOutputFile: car1021.out
  ILINK.IlinkIcfFile: C:\Documents and Settings\xiayf\桌面\hardware test\LM3S.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group lib
    ../../../../../../StellarisWare/driverlib/ewarm/Exe/: driverlib.a
  group src
    src/: delay.c infraredkey.c ISR.c keys.c led.c main.c motor.c nrf24l01.c
  group src/test
    src/: key_led_test.c motor_encoder_test.c walk_test.c wireless_comm_test.c
  group startup
    src/: startup.c
